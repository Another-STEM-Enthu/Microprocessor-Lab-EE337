//Deshpande Varad Shailesh
//21d070024

ORG 0H
LJMP MAIN
ORG 100H

MAIN:
LCALL FINDn // N in R5
MOV 30H, R5
MOV R0, #40H

LCALL FINDr // R6 <= r
BACK: MOV R0, #40H
MOV A, @R0
MOV R5, 30H

BACKIN:
MOV B, R6
MUL AB
MOV P1, A        //P1 in place of @P1
CALL DELAY 
DJNZ R5, BACKIN  //DJNZ in place of DJNE
LJMP BACK

ORG 200H
FINDn:
PUSH 0
MOV R0, #50H
MOV A, @R0
MOV R5, A //N
POP 0
RET

FINDr:
INC R0
MOV A, @R0
DEC R0
MOV B, @R0
DIV AB				//DIV is always AX and not XA
MOV R6, A
RET

DELAY:
PUSH ACC
PUSH B
PUSH 5
PUSH 6
MOV R5, #0FFH		//should add a 0 after the hash to specify that the letters are hex
MOV R6, #0FFH
HERE1: DEC R5
HERE2: DJNZ R6, HERE2
MOV A, R5
JNZ HERE1
POP 6
POP 5
POP B
POP ACC
RET

END